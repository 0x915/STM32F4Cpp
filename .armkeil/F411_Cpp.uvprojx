# Keil uVision project F411_Cpp.uvprojx, settings and files
target F411_Cpp (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F411_Cpp +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../_Application;../_Drivers/STM32F4xx_HAL_Driver/Inc;../_Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../_Drivers/CMSIS/Device/ST/STM32F4xx/Include;../_Drivers/CMSIS/Include;../_System
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group _Application
    ../_Application/: main.cpp basic.cpp stm32f4xx_hal_msp.c
  group _Drivers
    ../_Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group _System
    ../_System/: stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f411xe.s
software components: CMSIS:CORE 5.3.0
